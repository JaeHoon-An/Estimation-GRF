Commit message: update canine v2 leg urdf

File: rsc/urdf/canine_leg_left/canine_leg_left_V2.urdf (robot description, URDF)
Before this commit: robot canine-leg-left-V2, 6 links, 5 joints
Links:
- link hip_1: mass 0.7835 -> 1.8833
